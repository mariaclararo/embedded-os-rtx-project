# Keil uVision project CMSISrtxThreads.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: CMSISrtxThreads
  c flags: Optim=2 v6Lang=1 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Board Support:LED 2.0.0, Device:GPIO 1.2, Device:Startup 1.0.0
